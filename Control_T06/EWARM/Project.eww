<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Control_T06.ewp</path>
  </project>
  <batchBuild />
</workspace>
